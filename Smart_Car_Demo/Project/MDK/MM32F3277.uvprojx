# Keil uVision project MM32F3277.uvprojx, settings and files
target MM32F3277_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32F3277G9P MindMotion
  pack: MindMotion.MM32F327x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MM32F3277
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: ENABLEFSMC
  c include: ..\CODE;..\USER\src;..\USER\inc;..\..\Libraries\seekfree_libraries\common;..\..\\Libraries\seekfree_libraries\board;..\..\Libraries\seekfree_libraries\system;..\..\Libraries\seekfree_libraries;..\..\Libraries\seekfree_peripheral;..\..\Libraries\Device\CMSIS\KEIL_Core;..\..\Libraries\Device\MM32F327x\Include;..\..\Libraries\Device\MM32F327x\HAL_Lib\Inc;..\..\Libraries\rttherad_libraries\bsp;..\..\Libraries\rttherad_libraries\components\finsh;..\..\Libraries\rttherad_libraries\include;..\..\Libraries\rttherad_libraries\include\libc
  asm include: ..\..\Libraries\rttherad_libraries\libcpu\arm\cortex-m3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user_c
    ../USER/src/: isr.c main.c
  group user_h
    ../../Libraries/rttherad_libraries/bsp/: rtconfig.h
    ../USER/inc/: isr.h
  group CODE
    ../CODE/: 本文件夹作用.txt button.c button.h buzzer.c buzzer.h display.c display.h elec.c elec.h encoder.c encoder.h motor.c motor.h timer_pit.c timer_pit.h
  group board
    ../../Libraries/seekfree_libraries/board/: board.c board.h
  group common
    ../../Libraries/seekfree_libraries/common/: common.c common.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h SEEKFREE_FUN.c SEEKFREE_FUN.h
  group startup
    ../../Libraries/Device/MM32F327x/Source/: system_mm32f327x.c
    ../../Libraries/Device/MM32F327x/Source/KEIL_StartAsm/: startup_mm32f327x_keil.s
  group doc
    ../../Libraries/doc/: pin_recommend.txt version.txt
  group seekfree_libraries
    ../../Libraries/seekfree_libraries/: headfile.h zf_adc.c zf_adc.h zf_camera.c zf_camera.h zf_exti.c zf_exti.h zf_flash.c zf_flash.h zf_fsmc.c zf_fsmc.h zf_gpio.c zf_gpio.h zf_pit.c zf_pit.h zf_pwm.c zf_pwm.h zf_spi.c zf_spi.h zf_systick.c zf_systick.h zf_tim.c zf_tim.h zf_uart.c zf_uart.h
  group seekfree_peripheral
    ../../Libraries/seekfree_peripheral/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_ABSOLUTE_ENCODER.c SEEKFREE_ABSOLUTE_ENCODER.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_IPS200_PARALLEL8.c SEEKFREE_IPS200_PARALLEL8.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V03X.c SEEKFREE_MT9V03X.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_TSL1401.c SEEKFREE_TSL1401.h SEEKFREE_UART_7725.c SEEKFREE_UART_7725.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h SEEKFREE_WIRELESS.c SEEKFREE_WIRELESS.h
  group MM32_HAL
    ../../Libraries/Device/MM32F327x/HAL_Lib/Inc/: dtype.h hal_conf.h hal_device.h hal_redefine.h hal_adc.h hal_bkp.h hal_can.h hal_comp.h hal_crc.h hal_crs.h hal_dac.h hal_dbg.h hal_dma.h hal_eth.h hal_eth_conf.h hal_exti.h hal_flash.h hal_fsmc.h hal_gpio.h hal_i2c.h hal_iwdg.h hal_misc.h hal_pwr.h hal_rcc.h hal_rtc.h hal_sdio.h hal_spi.h hal_syscfg.h hal_tim.h hal_uart.h hal_uid.h hal_ver.h hal_wwdg.h
    ../../Libraries/Device/MM32F327x/HAL_Lib/Src/: hal_adc.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
  group rtthread_src
    ../../Libraries/rttherad_libraries/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group rtthread_inc
    ../../Libraries/rttherad_libraries/include/: rtdbg.h rtdebug.h rtdef.h rthw.h rtlibc.h rtm.h rtservice.h rtthread.h
    ../../Libraries/rttherad_libraries/include/libc/: libc_dirent.h libc_errno.h libc_fcntl.h libc_fdset.h libc_ioctl.h libc_limits.h libc_signal.h libc_stat.h libc_stdio.h
  group rtthread_lib
    ../../Libraries/rttherad_libraries/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group rtthread_components
    ../../Libraries/rttherad_libraries/components/finsh/: cmd.c finsh.h finsh_api.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_file.c shell.c shell.h symbol.c
